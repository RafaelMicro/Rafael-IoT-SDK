# IAR project CM3GP_all_green_power.ewp, settings and files
configuration CM3GP single project STM32L162xD (ARM, debug)
  General.OGChipSelectEditMenu: STM32L162xD ST STM32L162xD
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: xZB_TRACE_OVER_USART; ZB_TRACE_OVER_JTAG; ZB_PLATFORM_CORTEX_M3; DEBUG; STM32_E407; ZB_TRACE_LEVEL=16; ZB_TRACE_MASK=100; STM32F10X_CL; USE_STDPERIPH_DRIVER; GPHAL_NUMBER_OF_EVENTS_USED=0; GP_HAL_EXPECTED_PRODUCT_ID=GP710; MAIN_FUNCTION_NAME=gpSched_Task; GP_BSP_COM_UART_SELECT=5; PID_MOTION_SENSOR=1; CES_SENSOR_PID=PID_MOTION_SENSOR; GP_DIVERSITY_STM32L162RD_BOSCH; ST_LINK_CONNECTED; ZB_USE_ALARM_B; GP_NVM_NBR_OF_SECTIONS=2; xZB_OTA_BOOTLOADER; STM32_E407; STM32F10X_CL; USE_STDPERIPH_DRIVER; GPHAL_NUMBER_OF_EVENTS_USED=0; GP_HAL_EXPECTED_PRODUCT_ID=GP710; MAIN_FUNCTION_NAME=gpSched_Task; GP_BSP_COM_UART_SELECT=5; PID_MOTION_SENSOR=1; CES_SENSOR_PID=PID_MOTION_SENSOR; GP_DIVERSITY_STM32L162RD_BOSCH; ST_LINK_CONNECTED; ZB_USE_ALARM_B; GP_NVM_NBR_OF_SECTIONS=2; xUSE_GP710_CRYPTO_TX; xUSE_GP710_CRYPTO_RX; GP_SCHED_DEFAULT_GOTOSLEEP_THRES=5000; ZB_ENABLE_ZGP; ZB_ZGPD_ROLE; ZB_ZGPD_TEST_MODE; USE_ZB_MLME_SET_CONFIRM
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --no_path_in_file_macros
  ICCARM.CCIncludePath2: ..\..\..\include; ..\..\..\osif\include; ..\..\..\application\comcast\spi; ..\..\..\application\comcast\include; ..\..\..\..\gp_mac_cortexm3\comps\gpUtils\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpCom\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpWmrk\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpCom\src; ..\..\..\..\gp_mac_cortexm3\comps\gpLog\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpBaseComps\inc; ..\..\..\..\gp_mac_cortexm3\comps\halStm32l1xx\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpMac\inc; ..\..\..\..\gp_mac_cortexm3\comps\gphal\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpBsp\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpMac\src; ..\..\..\..\gp_mac_cortexm3\comps\gpAssert\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpReset\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpNvm\inc; ..\..\..\..\gp_mac_cortexm3\comps\gphal\src; ..\..\..\..\gp_mac_cortexm3\comps\gpSched\inc; ..\..\..\..\gp_mac_cortexm3\comps\gphal\inc\gp50x; ..\..\..\..\gp_mac_cortexm3\comps\gpHal\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpHal\inc\gp50x; ..\..\..\..\gp_mac_cortexm3\comps\gpTxMonitor\inc; ..\..\..\..\gp_mac_cortexm3\inc\compiler\IAR_ARM; ..\..\..\..\gp_mac_cortexm3\comps\gpSched\src; ..\..\..\..\gp_mac_cortexm3\comps\gpRamProgram\inc; ..\..\..\..\gp_mac_cortexm3\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpRamProgram\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpTxMonitor\inc; ..\..\..\application\remotec\include; ..\..\..\tests\ha\certification\include\; ..\..\..\zgp\include; ..\..\..\application\smart_plug\include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: CM3GP_all_green_power.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\build-configurations\stm32l1xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration ED single project (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ZB_ED_ROLE; DEBUG; STM32_E407; ZB_TRACE_LEVEL=10; STM32F10X_CL; USE_STDPERIPH_DRIVER; GPHAL_NUMBER_OF_EVENTS_USED=0; GP_BSP_COM_UART_SELECT=1; GP_HAL_EXPECTED_PRODUCT_ID=GP710; MAIN_FUNCTION_NAME=gpSched_Task
  ICCARM.CCIncludePath2: ..\..\..\include; ..\..\..\osif\include; ..\..\..\..\gp_mac_cortexm3\comps\gpUtils\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpCom\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpWmrk\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpCom\src; ..\..\..\..\gp_mac_cortexm3\comps\gpLog\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpBaseComps\inc; ..\..\..\..\gp_mac_cortexm3\comps\halStm32l1xx\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpMac\inc; ..\..\..\..\gp_mac_cortexm3\comps\gphal\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpBsp\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpMac\src; ..\..\..\..\gp_mac_cortexm3\comps\gpAssert\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpReset\inc; ..\..\..\..\gp_mac_cortexm3\comps\gphal\src; ..\..\..\..\gp_mac_cortexm3\comps\gpSched\inc; ..\..\..\..\gp_mac_cortexm3\comps\gphal\inc\gp50x; ..\..\..\..\gp_mac_cortexm3\comps\gpHal\inc; ..\..\..\..\gp_mac_cortexm3\comps\gpHal\inc\gp50x; ..\..\..\..\gp_mac_cortexm3\inc\compiler\IAR_ARM; ..\..\..\..\gp_mac_cortexm3\comps\gpSched\src; ..\..\..\..\gp_mac_cortexm3\inc
  OBJCOPY.OOCOutputFile: CM3GP_all.srec
  ILINK.IlinkIcfFile: ..\..\..\..\gp_mac_cortexm3\LinkerScripts\stm32l1xx_flash.icf
configuration ED single release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ZB_ED_ROLE; xDEBUG; STM32_E407; xZB_TRACE_LEVEL=10; STM32F10X_CL; USE_STDPERIPH_DRIVER; GPHAL_NUMBER_OF_EVENTS_USED=0; GP_BSP_COM_UART_SELECT=1; GP_HAL_EXPECTED_PRODUCT_ID=GP710; MAIN_FUNCTION_NAME=gpSched_Task
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: CM4GP_all.srec
  ILINK.IlinkIcfFile: as above
configuration Single ZC release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32l162xD ST STM32l162xD
  ICCARM.CCDefines: xDEBUG; STM32_E407; xZB_TRACE_LEVEL=10; STM32F10X_CL; USE_STDPERIPH_DRIVER; GPHAL_NUMBER_OF_EVENTS_USED=0; GP_BSP_COM_UART_SELECT=1; GP_HAL_EXPECTED_PRODUCT_ID=GP710; MAIN_FUNCTION_NAME=gpSched_Task
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: CM4GP_all.srec
  ILINK.IlinkIcfFile: as above
  group Application/zgpd_battery_value_is_0
    zgpd_battery_value_is_0/: door_sensor_device.c
  group Application/zgpd_lost_channel_config
    zgpd_lost_channel_config/: zgpd_lost_channel_config.c
  group Application/zgpd_lost_commissioning_reply
    zgpd_lost_commissioning_reply/: zgpd_lost_comm_reply.c
  group Application/zgpd_multiple_commissioning
    zgpd_multiple_commissioning/: door_sensor_device.c
  group Application/zgpd_multiple_commissioning_decommissioning
    zgpd_multiple_commissioning_decommissioning/: door_sensor_device.c
  group Application/zgpd_send_cmd_before_commissioning
    zgpd_send_cmd_before_commissioning/: door_sensor_device.c
  group Application/zgpd_unsupported_device_type
    zgpd_unsupported_device_type/: door_sensor_device.c
  group Application/zgpd_unsupported_manuf_spec_device_id
    zgpd_unsupported_manuf_spec_device_id/: door_sensor_device.c
  group Application/zgpd_unsupported_manuf_spec_id
    zgpd_unsupported_manuf_spec_id/: door_sensor_device.c
  group gp_mac/gpAssert
    ../../../../gp_mac_cortexm3/comps/gpAssert/src/: gpAssert.c
  group gp_mac/gpBaseComps
    ../../../../gp_mac_cortexm3/comps/gpBaseComps/src/: gpBaseComps_StackInit.c
  group gp_mac/gpBsp
    ../../../../gp_mac_cortexm3/comps/gpBsp/src/: gpBsp.c
  group gp_mac/gpCom
    ../../../../gp_mac_cortexm3/comps/gpCom/src/: gpCom.c gpCom_data.c gpCom_uart.c
  group gp_mac/gphal
    ../../../../gp_mac_cortexm3/comps/gphal/src/: gphal.c gphal_ES.c gphal_ES_Ext.c gphal_gp50x_ISR.c gphal_gp50x_ISR_Extern.c gphal_gp50x_MAC.c gphal_gp50x_MAC_ED.c gphal_gp50x_OTP.c gphal_gp50x_Reset.c gphal_gp50x_TxCalibration.c gphal_HW.c gphal_ISR.c gphal_MAC.c gphal_MAC_Ext.c gphal_MISC.c gphal_MSI.c gphal_Reset.c gphal_SEC.c gphal_Sleep.c
  group gp_mac/gpLog
    ../../../../gp_mac_cortexm3/comps/gpLog/src/: gpLog.c
  group gp_mac/gpMac
    ../../../../gp_mac_cortexm3/comps/gpMac/src/: gpMac.c gpMac_Association.c gpMac_DiagCntrs.c gpMac_Disassociation.c gpMac_IndirectTransmission.c gpMac_Reset.c gpMac_Scan.c gpMac_SetGet.c gpMac_SoftwareQueue.c gpMac_Start.c
  group gp_mac/gpNvm
    ../../../../gp_mac_cortexm3/comps/gpNvm/src/: gpNvm.c gpNvm_CheckConsistency.c
  group gp_mac/gpRamProgram
    ../../../../gp_mac_cortexm3/comps/gpRamProgram/src/: gpRamProgram.c
  group gp_mac/gpReset
    ../../../../gp_mac_cortexm3/comps/gpReset/src/: gpReset.c
  group gp_mac/gpSched
    ../../../../gp_mac_cortexm3/comps/gpSched/src/: gpSched.c gpSched_data.c
  group gp_mac/gpTxMonitor
    ../../../../gp_mac_cortexm3/comps/gpTxMonitor/src/: gpTxMonitor_DrvOffChip.c gpTxMonitor_DrvOnChip.c
  group gp_mac/gpUtils
    ../../../../gp_mac_cortexm3/comps/gpUtils/src/: gpUtils_AL.c gpUtils_ALext.c gpUtils_CircB.c gpUtils_crc.c gpUtils_crc32.c gpUtils_div64.c gpUtils_LL.c gpUtils_LLext.c gpUtils_log.c gpUtils_stack.c
  group gp_mac/halstm32l1xx
    ../../../../gp_mac_cortexm3/comps/halStm32l1xx/src/: adc_spi.c startup_stm32l1xx_hd.s
    ../../../../gp_mac_cortexm3/comps/halstm32l1xx/src/: hal.c hal_IOEx.c misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c system_stm32l1xx.c
  group kernel/aps
    ../../../aps/: aps_bind.c aps_commands.c aps_dups.c aps_internal.h aps_interpan.c aps_main.c aps_nwk_confirm.c
  group kernel/common
    ../../../common/: zb_address.c zb_bufpool.c zb_bufpool_init.c zb_debug.c zb_error_indication.c zb_ib.c zb_init.c zb_nvram.c zb_random.c zb_scheduler.c zb_scheduler_init.c zb_serial_trace.c zb_serial_trace_bin.c zb_time.c
  group kernel/gpmac
    ../../../osif/cortexm/gp/: gp_crypto_api.c
    ../../../gpmac/: zb_gpmac.c zb_gpmac_internal.h zb_gpmac_scheduler.c zb_gpmac_traffic_trace.c
  group kernel/mac
    ../../../mac/: mac_common.c mac_fcs.c
  group kernel/nwk
    ../../../nwk/: nwk_address_assign.c nwk_address_conflict.c nwk_cr_formation.c nwk_cr_join.c nwk_cr_mesh_routing.c nwk_cr_permit_join.c nwk_cr_route_discovery.c nwk_cr_tree_routing.c nwk_discovery.c nwk_formation.c nwk_internal.h nwk_join.c nwk_link_status.c nwk_main.c nwk_neighbor.c nwk_nlme.c nwk_panid_conflict.c nwk_srouting.c
  group kernel/secur
    ../../../secur/: aps_secur.c apsme_secur.c mac_secur.c nwk_secur.c secur_ccm.c zdo_secur.c
  group kernel/zcl
    ../../../zcl/: ha_ez_mode_comissioning.c ha_sas.c zcl_alarms_commands.c zcl_alarms_commands.h zcl_attr_value.c zcl_basic_commands.c zcl_basic_commands.h zcl_color_control_commands.c zcl_color_control_commands.h zcl_common.c zcl_continuous_value_change_commands.c zcl_diagnostics_commands.c zcl_diagnostics_commands.h zcl_general_commands.c zcl_groups.c zcl_ias_ace_commands.c zcl_ias_ace_commands.h zcl_ias_wd_commands.c zcl_ias_wd_commands.h zcl_ias_zone_commands.c zcl_ias_zone_commands.h zcl_identify_commands.c zcl_identify_commands.h zcl_level_control_commands.c zcl_level_control_commands.h zcl_main.c zcl_on_off_commands.c zcl_on_off_commands.h zcl_ota_upgrade_commands.c zcl_ota_upgrade_commands.h zcl_poll_control_client.c zcl_poll_control_commands.c zcl_poll_control_commands.h zcl_power_config_commands.c zcl_power_config_commands.h zcl_reporting.c zcl_scenes.c zcl_scenes_commands.h zcl_shade_config_commands.c zcl_shade_config_commands.h zcl_temp_measurement.c zcl_thermostat_commands.c
  group kernel/zdo
    ../../../zdo/: af_descriptor.c af_interpan.c af_rx.c test_profile.c zdo_app.c zdo_bind_manage.c zdo_channel_manager.c zdo_common.c zdo_common.h zdo_disc_cli.c zdo_disc_srv.c zdo_nwk_manage_cli.c zdo_nwk_manage_srv.c zdo_rx.c
  group kernel/zgp
    ../../../zgp/: zgp_common.c zgp_secur.c zgp_sink.c zgp_sink_table.c zgp_stub.c zgp_translation_table.c zgp_tx_queue.c zgp_zgpd.c zgp_zgpd_test.c
  group kernel/zll
    ../../../zll/: TI_aes_128.c zll_app.c zll_commissioning.c zll_device_discovery.c zll_identify.c zll_join_end_device.c zll_join_router.c zll_network_start.c zll_nwk_features.c zll_reset_factory.c zll_sas.c zll_secur.c
  group osif
    ../../../osif/cortexm/: zb_cortexm_nvram.c zb_cortexm_osless.c zb_jtag_trace.c zb_usart.c
