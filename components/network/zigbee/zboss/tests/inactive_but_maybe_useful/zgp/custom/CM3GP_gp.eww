<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CM3GP_all_green_power.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>test using libs - debug</name>
      <member>
        <project>MacLib</project>
        <configuration>GP MAC lib STM32F407ZG</configuration>
      </member>
      <member>
        <project>CM3GP_ker</project>
        <configuration>CM4GP_ker lib STM32F407ZG</configuration>
      </member>
      <member>
        <project>CM3GP_osif</project>
        <configuration>CM4GP_osif lib STM32F407ZG</configuration>
      </member>
      <member>
        <project>CM3GP_tests</project>
        <configuration>STM32F407ZG</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>test using libs - release</name>
      <member>
        <project>MacLib</project>
        <configuration>STM32F407ZG - release</configuration>
      </member>
      <member>
        <project>CM3GP_ker</project>
        <configuration>STM32F407ZG - release</configuration>
      </member>
      <member>
        <project>CM3GP_osif</project>
        <configuration>STM32F407ZG - release</configuration>
      </member>
      <member>
        <project>CM3GP_tests</project>
        <configuration>STM32F407ZG-release</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>tests ED libs debug</name>
      <member>
        <project>MacLib</project>
        <configuration>GP MAC lib STM32F407ZG</configuration>
      </member>
      <member>
        <project>CM3GP_osif</project>
        <configuration>CM3GP_osif lib STM32F407ZG</configuration>
      </member>
      <member>
        <project>CM3GP_ker</project>
        <configuration>ker lib ed debug stm32</configuration>
      </member>
      <member>
        <project>CM3GP_tests</project>
        <configuration>tests ed debug</configuration>
      </member>
    </batchDefinition>
    <batchDefinition>
      <name>sdk_ffd_rfd</name>
      <member>
        <project>MacLib</project>
        <configuration>GP MAC lib STM32L162RD</configuration>
      </member>
      <member>
        <project>CM3GP_ker</project>
        <configuration>ker lib ed debug stm32</configuration>
      </member>
      <member>
        <project>CM3GP_osif</project>
        <configuration>CM3GP_osif lib STM32L162xD</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


