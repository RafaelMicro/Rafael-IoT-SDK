#include <stdio.h>
#include <string.h>
#include <stdlib.h>
#include "hosal_crypto_aes.h"
#include "uart_stdio.h"


/*below test vector is RFC 4493 Test (Appendix A.) data*/
uint8_t key[HOSAL_AES_BLOCKLEN] =
{
    0x2b, 0x7e, 0x15, 0x16, 0x28, 0xae, 0xd2, 0xa6,
    0xab, 0xf7, 0x15, 0x88, 0x09, 0xcf, 0x4f, 0x3c
};

uint8_t plaintext_data[64] =
{
    0x6b, 0xc1, 0xbe, 0xe2, 0x2e, 0x40, 0x9f, 0x96,
    0xe9, 0x3d, 0x7e, 0x11, 0x73, 0x93, 0x17, 0x2a,
    0xae, 0x2d, 0x8a, 0x57, 0x1e, 0x03, 0xac, 0x9c,
    0x9e, 0xb7, 0x6f, 0xac, 0x45, 0xaf, 0x8e, 0x51,
    0x30, 0xc8, 0x1c, 0x46, 0xa3, 0x5c, 0xe4, 0x11,
    0xe5, 0xfb, 0xc1, 0x19, 0x1a, 0x0a, 0x52, 0xef,
    0xf6, 0x9f, 0x24, 0x45, 0xdf, 0x4f, 0x9b, 0x17,
    0xad, 0x2b, 0x41, 0x7b, 0xe6, 0x6c, 0x37, 0x10
};

uint8_t expected_encryption_text[64] =
{
    0x3a, 0xd7, 0x7b, 0xb4, 0x0d, 0x7a, 0x36, 0x60,
    0xa8, 0x9e, 0xca, 0xf3, 0x24, 0x66, 0xef, 0x97,
    0xf5, 0xd3, 0xd5, 0x85, 0x03, 0xb9, 0x69, 0x9d,
    0xe7, 0x85, 0x89, 0x5a, 0x96, 0xfd, 0xba, 0xaf,
    0x43, 0xb1, 0xcd, 0x7f, 0x59, 0x8e, 0xce, 0x23,
    0x88, 0x1b, 0x00, 0xe3, 0xed, 0x03, 0x06, 0x88,
    0x7b, 0x0c, 0x78, 0x5e, 0x27, 0xe8, 0xad, 0x3f,
    0x82, 0x23, 0x20, 0x71, 0x04, 0x72, 0x5d, 0xd4
};

/*
 *   g_encryption_text_buf/g_decryption_text_buf buffer
 *  used as "temp buffer" for below function used.
 *
 */

static uint8_t g_encryption_text_buf[128];

static uint8_t g_decryption_text_buf[128];

//------------------ ECC GF(2m) ------------------

int main(void) {
    
   
    uint32_t i;
    //AES-128, AES-128 test pattern
	hosal_aes_dev_t aes_dev;

    uart_stdio_init();
    printf("\r\n----------------------------------------------------------------\r\n");
    printf("Build Date:%s \r\n",__DATE__);
    printf("Build Time:%s \r\n",__TIME__);
    printf("----------------------------------------------------------------\r\n");
    printf("Examples    : hosal crypto aes 128 decrypt demo\r\n");
    printf("----------------------------------------------------------------\r\n");

    hosal_crypto_aes_init();

    for(i =0 ;i<64;i+=HOSAL_AES_BLOCKLEN)
    {
	    aes_dev.crypto_operation = HOSAL_AES_CRYPTO_DECRYPT;
	    aes_dev.bit = HOSAL_AES_128_BIT;
	    aes_dev.in_ptr = (expected_encryption_text+i);
	    aes_dev.out_ptr = (g_decryption_text_buf+i);
	    aes_dev.key_ptr = key;
	    hosal_crypto_aes_operation(&aes_dev);
    }

    if (memcmp((char *) plaintext_data, (char *) g_decryption_text_buf, 64) == 0)
    {
        printf(" AES_128_test hardware decryption  ECB: SUCCESS!\r\n");      /*decryption correct */
    }
    else
    {
        printf(" AES_128_test hardware decryption  ECB: FAILURE!\r\n");
    }

    printf("\r\n\r\n");
    printf("hosal crypto aes 128 decryption finish!\r\n");
    while (1);
}
